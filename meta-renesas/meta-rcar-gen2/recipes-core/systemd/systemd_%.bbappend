FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-Add-missing-define-to-header-of-old-porter-kernel.patch"
